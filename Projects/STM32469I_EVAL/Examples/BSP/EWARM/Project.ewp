# IAR project Project.ewp, settings and files
configuration STM32469I_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F469NI ST STM32F469NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F469xx; USE_STM32469I_EVAL; USE_IOEXPANDER; TS_MULTI_TOUCH_SUPPORTED
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32469I_EVAL; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Utilities\Log
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f469xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers
    ../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM4_IAR_wc32.a
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c
    ../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../../../../../Drivers/BSP/Components/s5k5cag/: s5k5cag.c
    ../../../../../Drivers/BSP/Components/ov5640/: ov5640.c
    ../../../../../Drivers/BSP/Components/wm8994/: wm8994.c
  group Drivers/BSP/STM32469I_EVAL
    ../../../../../Drivers/BSP/STM32469I_EVAL/: stm32469i_eval.c stm32469i_eval_audio.c stm32469i_eval_camera.c stm32469i_eval_eeprom.c stm32469i_eval_io.c stm32469i_eval_lcd.c stm32469i_eval_nor.c stm32469i_eval_qspi.c stm32469i_eval_sd.c stm32469i_eval_sdram.c stm32469i_eval_sram.c stm32469i_eval_ts.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_nor.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_fmc.c stm32f4xx_ll_sdmmc.c
  group Example/EWARM
    ./: startup_stm32f469xx.s
  group Example/User
    ../Src/: animation.c audio_play.c camera.c eeprom.c joystick.c lcd.c log.c main.c nor.c qspi.c sd.c sdram.c sdram_dma.c sram.c stm32f4xx_it.c touchscreen.c ts_calibration.c
  group Example/Utilities
    ../../../../../Utilities/Log/: lcd_log.c
