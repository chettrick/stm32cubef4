# Keil uVision project Project.uvprojx, settings and files
target STM32469I_EVAL (ARM-ADS)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.6
  cpu: IRAM(0x20000000-0x2004FFFF) IRAM2(0x10000000-0x2000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32469I_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F469xx,USE_STM32469I_EVAL,USE_IOEXPANDER,TS_MULTI_TOUCH_SUPPORTED
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\Drivers\BSP\STM32469I_EVAL;..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\Utilities\Log;..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Drivers
    ../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM4_Keil_wc16.lib
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/wm8994/: wm8994.c
    ../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c
    ../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../Drivers/BSP/Components/s5k5cag/: s5k5cag.c
    ../../../../../Drivers/BSP/Components/ov5640/: ov5640.c
    ../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
  group Example/MDK-ARM
    ./: startup_stm32f469xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dcmi.c stm32f4xx_hal_nor.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_uart.c stm32f4xx_hal_flash_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_fmc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_flash.c stm32f4xx_hal_pwr.c stm32f4xx_hal_sram.c stm32f4xx_hal_dma.c stm32f4xx_hal.c stm32f4xx_hal_dsi.c stm32f4xx_hal_sai.c stm32f4xx_hal_sd.c stm32f4xx_hal_gpio.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_qspi.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_ltdc_ex.c
  group Drivers/BSP/STM32469I_EVAL
    ../../../../../Drivers/BSP/STM32469I_EVAL/: stm32469i_eval_ts.c stm32469i_eval_sdram.c stm32469i_eval_sram.c stm32469i_eval.c stm32469i_eval_camera.c stm32469i_eval_lcd.c stm32469i_eval_eeprom.c stm32469i_eval_io.c stm32469i_eval_audio.c stm32469i_eval_nor.c stm32469i_eval_sd.c stm32469i_eval_qspi.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Example/User
    ../Src/: log.c camera.c nor.c joystick.c sdram.c sdram_dma.c main.c audio_play.c stm32f4xx_it.c ts_calibration.c qspi.c eeprom.c sram.c lcd.c touchscreen.c animation.c sd.c
  group Example/Utilities
    ../../../../../Utilities/Log/: lcd_log.c
software components: CMSIS:CORE 4.1.0
