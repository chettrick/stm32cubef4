# Keil uVision project Project.uvprojx, settings and files
target STM32469I_EVAL (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.1
  cpu: IRAM(0x20000000-0x2004FFFF) IRAM2(0x10000000-0x2000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32469I_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F469xx,USE_STM32469I_EVAL,USE_IOEXPANDER,_DLIB_FILE_DESCRIPTOR
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32469I_EVAL;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components;../../../../../../Middlewares/Third_Party/LwIP/src/include;../../../../../../Middlewares/Third_Party/LwIP/system;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Middlewares/Third_Party/FatFs/src/Drivers;../../../../../../Utilities;../../../../../../Utilities/Log
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Middlewares/FatFs/Drivers
    ../../../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_gpio.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_ll_fmc.c stm32f4xx_hal.c stm32f4xx_hal_flash.c stm32f4xx_hal_sdram.c stm32f4xx_hal_dma.c stm32f4xx_hal_uart.c stm32f4xx_hal_dsi.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c
  group Application/User
    ../Src/: main.c tftputils.c app_ethernet.c ethernetif.c tftpserver.c stm32f4xx_it.c
  group Middlewares/LwIP/Api
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: pppapi.c err.c netdb.c tcpip.c netifapi.c netbuf.c api_lib.c sockets.c api_msg.c
  group Middlewares/LwIP/Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: init.c tcp_in.c netif.c inet_chksum.c udp.c pbuf.c tcp.c lwip_timers.c raw.c sys.c def.c tcp_out.c memp.c dns.c stats.c mem.c
  group Doc
    ../: readme.txt
  group Application/MDK-ARM
    ./: startup_stm32f469xx.s
  group Middlewares/LwIP/Netif
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: etharp.c
  group Application/Utilities
    ../../../../../../Utilities/Log/: lcd_log.c
  group Drivers/BSP/STM32469I_EVAL
    ../../../../../../Drivers/BSP/STM32469I_EVAL/: stm32469i_eval_sd.c stm32469i_eval.c stm32469i_eval_lcd.c stm32469i_eval_io.c stm32469i_eval_sdram.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
  group Middlewares/LwIP/Core/IPv4
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4_addr.c autoip.c ip_frag.c ip4.c dhcp.c igmp.c icmp.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
software components: CMSIS:CORE 4.3.0
