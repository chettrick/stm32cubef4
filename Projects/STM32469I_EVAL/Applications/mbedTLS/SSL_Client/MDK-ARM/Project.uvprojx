# Keil uVision project Project.uvprojx, settings and files
target STM32479I_EVAL (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F479NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x50000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32479I_EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F479xx,USE_STM32469I_EVAL,USE_IOEXPANDER,USE_LCD,MBEDTLS_CONFIG_FILE="<mbedtls_config.h>"
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32469I_EVAL;../../../../../../Drivers/BSP/Components;../../../../../../Middlewares/Third_Party/LwIP/src/include/;../../../../../../Middlewares/Third_Party/LwIP/system;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../../Utilities/Log;../../../../../../Utilities/Fonts
  asm include: ROJ_DIR$\..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/User
    ../Src/: ssl_client.c stm32f4xx_hal_msp.c main.c net_sockets.c ethernetif.c hardware_rng.c stm32f4xx_it.c stm32f4xx_hal_timebase_tim.c
    ./: retarget.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_gpio.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_hash.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_uart.c stm32f4xx_hal_rng.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_ll_fmc.c stm32f4xx_hal_eth.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash.c stm32f4xx_hal_sdram.c stm32f4xx_hal_dma.c stm32f4xx_hal_cryp.c stm32f4xx_hal_dsi.c
  group Middlewares/LwIP/Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: inet_chksum.c tcp_in.c mem.c tcp_out.c udp.c init.c netif.c ip.c stats.c dns.c memp.c sys.c pbuf.c def.c timeouts.c tcp.c raw.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/LwIP/System
    ../../../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Middlewares/LwIP/Api
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: netdb.c sockets.c api_lib.c tcpip.c api_msg.c netifapi.c err.c netbuf.c
  group Application/MDK-ARM
    ./: startup_stm32f479xx.s
  group Application/Utilities
    ../../../../../../Utilities/Log/: lcd_log.c
  group Middlewares/LwIP/Netif
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: lowpan6.c ethernet.c
  group Drivers/BSP/STM32469I_EVAL
    ../../../../../../Drivers/BSP/STM32469I_EVAL/: stm32469i_eval_lcd.c stm32469i_eval.c stm32469i_eval_io.c stm32469i_eval_sdram.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
  group Middlewares/mbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: memory_buffer_alloc.c nist_kw.c ssl_srv.c threading.c ssl_cookie.c pem.c x509_crl.c padlock.c ripemd160.c cipher_wrap.c asn1parse.c debug.c entropy.c ecjpake.c pk.c pkparse.c pkcs12.c md_wrap.c md5.c xtea.c ecdh.c error.c entropy_poll.c x509write_csr.c blowfish.c md.c certs.c chacha20.c chachapoly.c md2.c sha256.c ecdsa.c rsa.c havege.c platform.c hmac_drbg.c pk_wrap.c x509write_crt.c version_features.c asn1write.c bignum.c des.c ssl_cli.c camellia.c ctr_drbg.c ssl_tls.c ssl_ticket.c x509_crt.c timing.c ecp_curves.c version.c cmac.c pkcs5.c ssl_cache.c x509_csr.c sha512.c pkwrite.c oid.c x509.c aesni.c ccm.c aes.c gcm.c cipher.c sha1.c x509_create.c ssl_ciphersuites.c dhm.c md4.c arc4.c pkcs11.c base64.c ecp.c aria.c platform_util.c poly1305.c hkdf.c rsa_internal.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: queue.c timers.c list.c croutine.c tasks.c event_groups.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/LwIP/Core/IPv4
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4_frag.c igmp.c icmp.c ip4.c autoip.c etharp.c ip4_addr.c dhcp.c
software components: CMSIS:CORE 4.3.0
