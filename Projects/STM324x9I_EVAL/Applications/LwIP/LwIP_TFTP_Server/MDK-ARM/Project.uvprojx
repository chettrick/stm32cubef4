# Keil uVision project Project.uvprojx, settings and files
target STM324x9I_EVAL (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F429NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.1
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM324x9I_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STM324x9I_EVAL
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM324x9I_EVAL;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components;../../../../../../Middlewares/Third_Party/LwIP/src/include;../../../../../../Middlewares/Third_Party/LwIP/src/include/lwip                                   ;../../../../../../Middlewares/Third_Party/LwIP/src/include/netif;../../../../../../Middlewares/Third_Party/LwIP/system;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Middlewares/Third_Party/FatFs/src/Drivers;../../../../../../Utilities;../../../../../../Utilities/Log
  asm include: ROJ_DIR$\..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/Utilities
    ../../../../../../Utilities/Log/: lcd_log.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c ff.c diskio.c
  group Application/User
    ../Src/: app_ethernet.c ethernetif.c stm32f4xx_it.c tftpserver.c tftputils.c main.c
  group Drivers/BSP/STM324x9I_EVAL
    ../../../../../../Drivers/BSP/STM324x9I_EVAL/: stm324x9i_eval_sd.c stm324x9i_eval_lcd.c stm324x9i_eval_io.c stm324x9i_eval_sdram.c stm324x9i_eval.c
  group Middlewares/LwIP/Core/IPv4
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4_addr.c ip_frag.c autoip.c ip4.c dhcp.c igmp.c icmp.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FatFs/Drivers
    ../../../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_uart.c stm32f4xx_hal.c stm32f4xx_hal_sdram.c stm32f4xx_hal_sd.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_dma.c stm32f4xx_hal_i2c_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c
  group Middlewares/LwIP/Api
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: api_msg.c netifapi.c netbuf.c tcpip.c err.c pppapi.c netdb.c api_lib.c sockets.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../../../../../Drivers/BSP/Components/stmpe1600/: stmpe1600.c
  group Middlewares/LwIP/Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: raw.c inet_chksum.c lwip_timers.c def.c init.c netif.c udp.c pbuf.c tcp_out.c tcp.c sys.c tcp_in.c mem.c memp.c dns.c stats.c
  group Middlewares/LwIP/Netif
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: etharp.c
  group Doc
    ../: readme.txt
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
software components: CMSIS:CORE 4.3.0
