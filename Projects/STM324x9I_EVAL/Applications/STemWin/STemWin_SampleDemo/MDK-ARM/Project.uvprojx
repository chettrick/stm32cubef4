# Keil uVision project Project.uvprojx, settings and files
target STM324x9I_EVAL_MB1046 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F429NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM324x9I_EVAL_MB1046
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STM324x9I_EVAL,USE_MB1046
  c misc: --C99
  c include: ../Inc;../Demo;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM324x9I_EVAL;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components;../../../../../../Middlewares/ST/STemWin/inc;../../../../../../Utilities;../../../../../../Utilities/Fonts
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Middlewares/STemWin/Config
    ../../../../../../Middlewares/ST/STemWin/OS/: GUI_X.c
    ../Src/: LCDConf_stm324x9i_eval_MB1046.c GUIConf.c LCDConf_stm324x9i_eval_MB1063.c
  group Application/User
    ../Src/: rtc.c main.c calibration.c stm32f4xx_it.c
  group Drivers/BSP/STM324x9I_EVAL
    ../../../../../../Drivers/BSP/STM324x9I_EVAL/: stm324x9i_eval.c stm324x9i_eval_ts.c stm324x9i_eval_sdram.c stm324x9i_eval_io.c
  group Doc
    ../: readme.txt
  group Middlewares/STemWin/Lib
    ../../../../../../Middlewares/ST/STemWin/Lib/: STemWin532_CM4_Keil.lib
  group Application/Demo
    ../Demo/: GUIDEMO_Intro.c GUIDEMO_Speed.c GUIDEMO_Automotive.c GUIDEMO_Graph.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_VScreen.c GUIDEMO_ImageFlow.c GUIDEMO_ZoomAndRotate.c GUIDEMO_Listview.c GUIDEMO_Skinning.c GUIDEMO_IconView.c GUIDEMO_ColorBar.c GUIDEMO_Fading.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_RadialMenu.c GUIDEMO_Treeview.c GUIDEMO_Speedometer.c GUIDEMO_Bitmap.c GUIDEMO.c GUIDEMO_Resource.c GUIDEMO_AntialiasedText.c GUIDEMO_BarGraph.c GUIDEMO_WashingMachine.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_sdram.c stm32f4xx_hal_rtc.c stm32f4xx_hal_crc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal.c stm32f4xx_hal_rtc_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_dma.c stm32f4xx_hal_rng.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_i2c.c stm32f4xx_hal_tim.c
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../../../../../Drivers/BSP/Components/ts3510/: ts3510.c
    ../../../../../../Drivers/BSP/Components/exc7200/: exc7200.c
    ../../../../../../Drivers/BSP/Components/stmpe1600/: stmpe1600.c
target STM324x9I_EVAL_MB1063 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F429NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: as above
  output: STM324x9I_EVAL_MB1063
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STM324x9I_EVAL,USE_MB1063
  c misc: --C99
  c include: as above
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 4.3.0
