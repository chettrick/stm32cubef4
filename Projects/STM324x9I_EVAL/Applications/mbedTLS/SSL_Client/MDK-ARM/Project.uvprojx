# Keil uVision project Project.uvprojx, settings and files
target STM324x9I_EVAL (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F439NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM324x9I_EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F439xx,USE_STM324x9I_EVAL,USE_LCD,MBEDTLS_CONFIG_FILE="<mbedtls_config.h>"
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM324x9I_EVAL;../../../../../../Drivers/BSP/Components;../../../../../../Middlewares/Third_Party/LwIP/src/include/;../../../../../../Middlewares/Third_Party/LwIP/system;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../../Utilities/Log;../../../../../../Utilities/Fonts
  asm include: ROJ_DIR$\..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Application/User
    ../Src/: hardware_rng.c ethernetif.c stm32f4xx_hal_timebase_tim.c stm32f4xx_it.c net_sockets.c main.c stm32f4xx_hal_msp.c ssl_client.c
    ./: retarget.c
  group Drivers/BSP/STM324x9I_EVAL
    ../../../../../../Drivers/BSP/STM324x9I_EVAL/: stm324x9i_eval_lcd.c stm324x9i_eval_io.c stm324x9i_eval_sdram.c stm324x9i_eval.c
  group Middlewares/LwIP/Core/IPv4
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4_addr.c autoip.c igmp.c icmp.c etharp.c ip4_frag.c ip4.c dhcp.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c croutine.c timers.c list.c tasks.c queue.c
  group Utilities
    ../../../../../../Utilities/Log/: lcd_log.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_cortex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_flash.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_tim.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_rng.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_cryp.c stm32f4xx_hal_hash.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/LwIP/Api
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: api_msg.c netifapi.c api_lib.c sockets.c netbuf.c tcpip.c err.c netdb.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../../../../../Drivers/BSP/Components/stmpe1600/: stmpe1600.c
  group Middlewares/LwIP/Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: ip.c def.c init.c timeouts.c netif.c udp.c pbuf.c tcp_out.c mem.c dns.c stats.c raw.c inet_chksum.c tcp.c sys.c tcp_in.c memp.c
  group Middlewares/mbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: ecp_curves.c pkcs11.c arc4.c aria.c camellia.c x509.c ssl_cache.c bignum.c ctr_drbg.c ssl_tls.c platform.c platform_util.c poly1305.c pkcs5.c pkwrite.c x509_crt.c timing.c version.c ssl_ticket.c cipher.c sha1.c havege.c hkdf.c des.c dhm.c ssl_cli.c ecp.c asn1write.c ssl_ciphersuites.c x509_create.c version_features.c md_wrap.c x509write_crt.c aes.c pk.c ecdsa.c hmac_drbg.c blowfish.c pk_wrap.c x509write_csr.c cmac.c md2.c sha256.c x509_csr.c debug.c md.c pkparse.c entropy_poll.c ecdh.c ecjpake.c md5.c aesni.c ssl_cookie.c pem.c x509_crl.c pkcs12.c ripemd160.c threading.c memory_buffer_alloc.c nist_kw.c padlock.c asn1parse.c cipher_wrap.c base64.c rsa.c rsa_internal.c ccm.c ssl_srv.c gcm.c certs.c chacha20.c chachapoly.c md4.c xtea.c oid.c error.c entropy.c sha512.c
  group Middlewares/LwIP/Netif
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c lowpan6.c
  group Doc
    ../: readme.txt
  group Middlewares/LwIP/System
    ../../../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Application/MDK-ARM
    ./: startup_stm32f439xx.s
software components: CMSIS:CORE 4.3.0
