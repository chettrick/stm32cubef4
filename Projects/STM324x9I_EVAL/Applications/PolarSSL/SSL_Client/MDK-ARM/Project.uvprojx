# Keil uVision project Project.uvprojx, settings and files
target STM324x9I_EVAL (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F439NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.1
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM324x9I_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F439xx,USE_STM324x9I_EVAL
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM324x9I_EVAL;../../../../../../Drivers/BSP/Components;../../../../../../Middlewares/Third_Party/LwIP/src/include/;../../../../../../Middlewares/Third_Party/LwIP/src/include/ipv4;../../../../../../Middlewares/Third_Party/LwIP/system;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/Third_Party/polarssl/include;../../../../../../Utilities;../../../../../../Utilities/Fonts
  asm include: ROJ_DIR$\..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Application/User
    ../Src/: ethernetif.c stm32f4xx_hal_timebase_tim.c stm32f4xx_it.c main.c app_ethernet.c stm32f4xx_hal_msp.c ssl_client.c
    ./: retarget.c
  group Drivers/BSP/STM324x9I_EVAL
    ../../../../../../Drivers/BSP/STM324x9I_EVAL/: stm324x9i_eval_lcd.c stm324x9i_eval_io.c stm324x9i_eval_sdram.c stm324x9i_eval.c
  group Middlewares/LwIP/Core/IPv4
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4_addr.c ip_frag.c autoip.c igmp.c icmp.c ip4.c dhcp.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c timers.c list.c tasks.c queue.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_cortex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_flash.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_tim.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_rng.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_cryp.c stm32f4xx_hal_hash.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/LwIP/Api
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: api_msg.c netifapi.c api_lib.c sockets.c netbuf.c tcpip.c err.c pppapi.c netdb.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../../../../../Drivers/BSP/Components/stmpe1600/: stmpe1600.c
  group Middlewares/LwIP/Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: def.c init.c netif.c udp.c pbuf.c tcp_out.c mem.c dns.c stats.c raw.c inet_chksum.c lwip_timers.c tcp.c sys.c tcp_in.c memp.c
  group Middlewares/PolarSSL
    ../../../../../../Middlewares/Third_Party/PolarSSL/library/: padlock.c havege.c pem.c pkcs5.c rsa.c sha2.c md.c md2.c ssl_srv.c camellia.c bignum.c md_wrap.c sha4.c timing.c ssl_cache.c asn1parse.c pkcs12.c asn1write.c md5.c net.c ctr_drbg.c blowfish.c ssl_cli.c cipher_wrap.c version.c error.c entropy_poll.c x509write.c ssl_tls.c sha1.c pbkdf2.c debug.c cipher.c arc4.c pkcs11.c aes.c entropy.c des.c gcm.c xtea.c dhm.c base64.c certs.c x509parse.c md4.c
  group Middlewares/LwIP/Netif
    ../../../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: etharp.c
  group Doc
    ../: readme.txt
  group Application/MDK-ARM
    ./: startup_stm32f439xx.s
software components: CMSIS:CORE 4.3.0
