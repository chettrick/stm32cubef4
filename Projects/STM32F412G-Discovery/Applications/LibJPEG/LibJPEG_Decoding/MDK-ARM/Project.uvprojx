# Keil uVision project Project.uvprojx, settings and files
target STM32412G_DISCOVERY (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F412ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.1
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x08000000-0x080FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32412G_DISCOVERY
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: STM32F412Zx,USE_HAL_DRIVER,USE_STM32412G_DISCOVERY
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32412G-Discovery;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/Third_Party/LibJPEG/include;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Middlewares/Third_Party/FatFs/src/Drivers;../../../../../../Utilities/Log;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/BSP/STM32412G-Discovery
    ../../../../../../Drivers/BSP/STM32412G-Discovery/: stm32412g_discovery.c stm32412g_discovery_sd.c stm32412g_discovery_lcd.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c diskio.c ff.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_sd.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_sram.c stm32f4xx_hal_dma.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c
  group Middlewares/LibJPEG
    ../../../../../../Middlewares/Third_Party/LibJPEG/source/: jutils.c jidctfst.c jdatadst.c jaricom.c jdmarker.c jfdctfst.c jcarith.c jfdctint.c jdmaster.c jcdctmgr.c jfdctflt.c jcapistd.c jdmainct.c jdapistd.c jdhuff.c jccolor.c jcparam.c jidctflt.c jdsample.c jquant2.c jdmerge.c jdapimin.c jquant1.c jddctmgr.c jdpostct.c jcprepct.c jerror.c jcmainct.c jdcoefct.c jcmarker.c jchuff.c jcinit.c jdinput.c jctrans.c jmemmgr.c jdarith.c jidctint.c jccoefct.c jcsample.c jcomapi.c jcmaster.c jmemnobs.c jdtrans.c jcapimin.c jdcolor.c jdatasrc.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ls016b8uy/: ls016b8uy.c
    ../../../../../../Drivers/BSP/Components/st7789h2/: st7789h2.c
  group Application/User
    ../Src/: stm32f4xx_it.c main.c decode.c
  group Application/MDK-ARM
    ./: startup_stm32f412zx.s
  group Doc
    ../: readme.txt
  group Middlewares/FatFs/Drivers
    ../../../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
software components: CMSIS:CORE 4.3.0
