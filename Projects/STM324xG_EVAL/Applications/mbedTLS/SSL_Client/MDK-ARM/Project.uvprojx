# Keil uVision project Project.uvprojx, settings and files
target STM3241G_EVAL (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F417IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM3241G_EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F417xx,USE_STM324xG_EVAL,USE_LCD,MBEDTLS_CONFIG_FILE="<mbedtls_config.h>"
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM324xG_EVAL;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components;../../../../../../Middlewares/Third_Party/LwIP/src/include/;../../../../../../Middlewares/Third_Party/LwIP/system;../../../../../../Middlewares/Third_Party/LwIP/system/OS;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../../Utilities/Log;../../../../../../Utilities/Fonts
  asm include: ROJ_DIR$\..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Middlewares/LwIP/System
    ../../../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Utilities
    ../../../../../../Utilities/Log/: lcd_log.c
  group Middlewares/LwIP/Api
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: err.c netbuf.c netifapi.c tcpip.c api_lib.c api_msg.c sockets.c netdb.c
  group Application/User
    ../Src/: hardware_rng.c main.c ssl_client.c stm32f4xx_it.c ethernetif.c stm32f4xx_hal_timebase_tim.c net_sockets.c stm32f4xx_hal_msp.c
    ./: retarget.c
  group Application/MDK-ARM
    ./: startup_stm32f417xx.s
  group Middlewares/LwIP/Core/IPv4
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4.c ip4_addr.c dhcp.c icmp.c ip4_frag.c autoip.c igmp.c etharp.c
  group Drivers/BSP/STM324xG_EVAL
    ../../../../../../Drivers/BSP/STM324xG_EVAL/: stm324xg_eval_lcd.c stm324xg_eval_sram.c stm324xg_eval_io.c stm324xg_eval.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_uart.c stm32f4xx_hal_cortex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_dma.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_eth.c stm32f4xx_hal_sram.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_hash.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_3.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Doc
    ../: readme.txt
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: timers.c queue.c list.c croutine.c event_groups.c tasks.c
  group Middlewares/LwIP/Netif
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c lowpan6.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/mbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: entropy_poll.c timing.c ecdh.c aesni.c pkwrite.c threading.c cmac.c asn1parse.c dhm.c arc4.c entropy.c platform.c sha256.c ssl_cookie.c pkcs11.c ssl_ticket.c ssl_cache.c cipher.c ecdsa.c aes.c xtea.c pkcs12.c md_wrap.c md4.c base64.c gcm.c camellia.c sha512.c x509_csr.c x509_create.c ecjpake.c ripemd160.c x509write_crt.c md.c asn1write.c ssl_ciphersuites.c bignum.c des.c pem.c ssl_cli.c x509_crl.c ecp.c ecp_curves.c ssl_srv.c md2.c ctr_drbg.c md5.c pkparse.c cipher_wrap.c memory_buffer_alloc.c nist_kw.c pk.c pkcs5.c padlock.c x509write_csr.c havege.c certs.c chacha20.c chachapoly.c error.c x509.c debug.c sha1.c version.c ccm.c x509_crt.c rsa.c ssl_tls.c hmac_drbg.c blowfish.c oid.c version_features.c pk_wrap.c aria.c platform_util.c poly1305.c hkdf.c rsa_internal.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ili9325/: ili9325.c
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Middlewares/LwIP/Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: udp.c dns.c pbuf.c netif.c ip.c memp.c inet_chksum.c stats.c tcp.c init.c def.c timeouts.c raw.c tcp_out.c sys.c tcp_in.c mem.c
software components: CMSIS:CORE 4.3.0
