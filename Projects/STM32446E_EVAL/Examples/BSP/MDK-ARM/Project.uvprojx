# Keil uVision project Project.uvprojx, settings and files
target STM32446E_EVAL (ARM-ADS)
  device: STM32F446ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.6
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32446E_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F446xx,USE_STM32446E_EVAL,USE_IOEXPANDER
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\Drivers\BSP\STM32446E_EVAL;..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\Utilities\Log
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_fmpi2c.c stm32f4xx_hal.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_qspi.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_fmc.c stm32f4xx_hal_uart.c stm32f4xx_hal_sram.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_dma.c stm32f4xx_hal_sd.c stm32f4xx_hal_gpio.c stm32f4xx_hal_sai.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Example/Utilities
    ../../../../../Utilities/Log/: lcd_log.c
  group Example/MDK-ARM
    ./: startup_stm32f446xx.s
  group Example/User
    ../Src/: eeprom.c audio.c qspi.c sd.c touchscreen.c log.c ts_calibration.c stm32f4xx_it.c camera.c lcd.c joystick.c sdram.c main.c
  group Drivers/BSP/STM32446E_EVAL
    ../../../../../Drivers/BSP/STM32446E_EVAL/: stm32446e_eval_eeprom.c stm32446e_eval_io.c stm32446e_eval.c stm32446e_eval_sd.c stm32446e_eval_sdram.c stm32446e_eval_audio.c stm32446e_eval_qspi.c stm32446e_eval_camera.c stm32446e_eval_lcd.c stm32446e_eval_ts.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/wm8994/: wm8994.c
    ../../../../../Drivers/BSP/Components/s5k5cag/: s5k5cag.c
    ../../../../../Drivers/BSP/Components/ov5640/: ov5640.c
    ../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../Drivers/BSP/Components/ili9325/: ili9325.c
  group Doc
    ../: readme.txt
  group Middlewares/PDM
    ../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM4_Keil_wc16.lib
software components: CMSIS:CORE 3.40.0
