# IAR project Project.ewp, settings and files
configuration STM32446E-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F446ZE ST STM32F446ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F446xx; USE_STM32446E_EVAL; USE_IOEXPANDER
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\Drivers\BSP\STM32446E_EVAL; ..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\Drivers\BSP\Components\mfxstm32l152; ..\..\..\..\Drivers\BSP\Components\ili9325; ..\..\..\..\Drivers\BSP\Components\s5k5cag; ..\..\..\..\Drivers\BSP\Components\wm8994; ..\..\..\..\Utilities\Log; ..\..\..\..\Utilities\Fonts; ..\..\..\..\Utilities\CPU
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM3240G-EVAL.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f446xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../Drivers/BSP/Components/ili9325/: ili9325.c
    ../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../Drivers/BSP/Components/s5k5cag/: s5k5cag.c
    ../../../../Drivers/BSP/Components/wm8994/: wm8994.c
    ../../../../Drivers/BSP/Components/ov5640/: ov5640.c
  group Drivers/BSP/STM32446E-EVAL
    ../../../../Drivers/BSP/STM32446E_EVAL/: stm32446e_eval.c stm32446e_eval_audio.c stm32446e_eval_camera.c stm32446e_eval_eeprom.c stm32446e_eval_io.c stm32446e_eval_lcd.c stm32446e_eval_sd.c stm32446e_eval_sdram.c stm32446e_eval_ts.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group Example/EWARM
    ./: startup_stm32f446xx.s
  group Example/User
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
