# IAR project Project.ewp, settings and files
configuration STM32446E_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F446ZE ST STM32F446ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F446xx; USE_STM32446E_EVAL; USE_IOEXPANDER
  ICCARM.CCIncludePath2: ..\Inc; ..\Demo; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32446E_EVAL; ..\..\..\..\..\..\Drivers\BSP\Components\mfxstm32l152; ..\..\..\..\..\..\Drivers\BSP\Components\ili9325; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\Components; ..\..\..\..\..\..\Middlewares\ST\STemWin\inc; ..\..\..\..\..\..\Utilities; ..\..\..\..\..\..\Utilities\Fonts
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f446_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/Demo
    ../Demo/: GUIDEMO.c GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group Application/EWARM
    ./: startup_stm32f446xx.s
  group Application/User
    ../Src/: calibration.c main.c rtc.c stm32f4xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ili9325/: ili9325.c
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
  group Drivers/BSP/STM32446E_EVAL
    ../../../../../../Drivers/BSP/STM32446E_EVAL/: stm32446e_eval.c stm32446e_eval_io.c stm32446e_eval_ts.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_fmc.c
  group Middlewares/STemWin/Config
    ../../../../../../Middlewares/ST/STemWin/OS/: GUI_X.c
    ../Src/: GUIConf_stm32446e_eval.c LCDConf_stm32446e_eval.c
  group Middlewares/STemWin/Lib
    ../../../../../../Middlewares/ST/STemWin/Lib/: STemWin532_CM4_IAR.a
